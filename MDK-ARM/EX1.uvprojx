# Keil uVision project EX1.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F429NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EX1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ..\APP\inc;..\BSP\inc;..\CMSIS\inc;..\STM32F4xx_HAL_Driver\Inc;..\Third_Party\FreeRTOS\include;..\Third_Party\FreeRTOS\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c LED.c
    ../APP/inc/: stm32f4xx_hal_conf.h
  group BSP
    ../BSP/src/: bsp.c USART_DMA.c
  group CMSIS
    ../CMSIS/src/: system_stm32f4xx.c
  group STLIB
    ../STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c
  group StartUp
    ../Start_Up/: startup_stm32f429xx.s
  group FreeRTOS
    ../Third_Party/FreeRTOS/: croutine.c event_groups.c list.c queue.c readme.txt stream_buffer.c tasks.c timers.c
    ../Third_Party/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../Third_Party/FreeRTOS/portable/MemMang/: heap_4.c
